# Autodesk Inventor assembly: 28.0501 MODULE LR6 Z 90
## iProperties
Created: 2007-07
Part Number: 28.0501 MODULE LR6 Z 90
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
